# Keil uVision project CACHIP_Project.uvproj, settings and files
target CA51F152S4X_S6X (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: INT +hex
  AfterMake: CA51_make_all.bat
  c flags: Optimize=9
  c include: .\Device_MCU\CA51F152S4X_S6X_Library;.\Device_MCU\CA51F152S4X_S6X_Library\Includes;.\Device_MCU\CA51F152S4X_S6X_Library\TS_Lib\Sources;.\Device_MCU\CA51F152S4X_S6X_Library\TS_Lib\Includes;.\sys_source;.\sys_include;.\user_source;.\Display_drive
  asm include: .\Lib
  link misc: REMOVEUNUSED
  group Lib
    ./Lib/: STARTUP.A51
  group CA51F152S4X_S6X_Library
    ./Device_MCU/CA51F152S4X_S6X_Library/Sources/: adc.c delay.c flash.c i2c.c interrupt.c lvd.c pwm.c spi.c stop_idle.c system_clock.c system_init.c timer.c uart.c wdt.c
    ./Device_MCU/CA51F152S4X_S6X_Library/TS_Lib/Sources/: ts_api.c ts_debug.c ts_service.LIB ts_service_small.LIB
  group sys_source
    ./sys_source/: system_proc.c interrupt_proc.c uart_debug.c main.c msg.c init.c
  group user_source
    ./user_source/: user_app.c user_includes.h user_app.h
    ./sys_include/: user_config.h
  group Readme
    ./: 更新说明.txt
